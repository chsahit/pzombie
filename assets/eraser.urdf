Commit message: well at least pick works

File: assets/eraser.urdf (robot description, URDF)
Before this commit: robot eraser, 1 links, 0 joints
Links:
- link eraser: mass 0.5 -> 0.05
