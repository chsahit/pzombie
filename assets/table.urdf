Commit message: more reasonable action spec, table to scale

File: assets/table.urdf (robot description, URDF)
Before this commit: robot table, 1 links, 0 joints
Links:
- link box: geometry collision box size=1.53 1.22 0.7; visual box size=1.53 1.22 0.7
